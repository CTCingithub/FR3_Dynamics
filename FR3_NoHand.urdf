Commit message: Updated on 2024.02.17

File: FR3_NoHand.urdf (robot description, URDF)
Before this commit: robot fr3, 17 links, 17 joints
Joints:
- removed joint fr3_hand_joint
